# Repository DarwinNE/GEM_turbokit

File README.md:

# GEM_turbokit

This project is a modern version of the original Turbokit offered by Generalmusic for the S2/S3 series of synthesizers.
Installing this kit requires a certain degree of modification of the original board of the synth. Do not attempt it if you are not acquainted with such projects.

If you are interested in this project, [read this article, first](http://davbucci.chez-alice.fr/index.php?argument=elettronica/gem_s2/gem_s2.inc).

## The board

I routed a 4-layer board with stack PWR/signal/signal/GND, that is a little unusual. Here are pictures of the four layers of the version 1.0 of the board.

## Sources

The main inspiration for this project came from this page: https://www.hackster.io/DitroniX/gem-generalmusic-s2-s3-series-synth-retrofit-turbokit-c30f63

I carefully checked DitroniX's schematics along with the original GEM's Turbokit and things seem to align. I chose to follow DitroniX route for the configuration of the SCSI select lines.

## LICENSE

All this work is licensed under GPLv3.

## KiCad design turbokit_replica.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C9, C11, C12, C13, C14, C15, C16, C17, C18: 100nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C8: 6.8pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C10: 47µF; CP_Elec_5x5.8
C19: 10µF; CP_Elec_5x5.8
F1: 800mA; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
H1, H2, H3, H4, H5: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
J1: Right EPROM (IC34 lower); DIP-32_W15.24mm
J2: Left EPROM (IC32 higher); DIP-32_W15.24mm
J3: Conn_01x09_Pin; PinHeader_1x09_P2.54mm_Vertical
J4: Conn_01x06_Pin; Hirose_DF63-6P-3.96DSA_1x06_P3.96mm_Vertical
J5: 3.6V NiMH; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J6: SCSI; IDC-Header_2x17_P2.54mm_Vertical
JP4, JP5, JP6: SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm_NumberLabels
Q1: BC847; SOT-23
Q2: BC859; SOT-23
R1, R2: 82R; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R3: 2.7kΩ; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R4, R5, R6: 4.7kΩ; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R7: 220Ω; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
RN1, RN2, RN3, RN4, RN5: EXB2HV470JV; R_Array_Convex_8x0602
RN6: EXB28V470JX; R_Array_Concave_4x0603
U1: 74HC00; SOIC-14_3.9x8.7mm_P1.27mm
U2, U3, U4, U5: EPROM; DIP-32_W15.24mm_Socket
U6: 74HC32; SOIC-14_3.9x8.7mm_P1.27mm
U7, U8, U9, U10: AS6C4008; Renesas_SOP-32_11.4x20.75mm_P1.27mm
U11: 74HC139; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C9.1, C10.1, C11.1, C17.1, J1.1, J1.32, J2.1, J2.32, J4.4, J6.4, J6.6, J6.8, Q2.2 (E), R5.1, R6.1, U1.14 (VCC), U2.1 (VPP), U2.32 (VCC), U3.1 (VPP), U3.32 (VCC), U4.1 (VPP), U4.32 (VCC), U5.1 (VPP), U5.32 (VCC), U6.14 (VCC), U11.16 (VCC)
+VB: C12.2, C13.2, C14.2, C15.2, C18.1, C19.1, J3.4, J4.3, Q2.1 (B), Q2.3 (C), R4.1, R7.1, U7.32 (VCC), U8.32 (VCC), U9.32 (VCC), U10.32 (VCC)
/+BATT: F1.2, R7.2
/+BATT_IN: C16.1, F1.1, J4.6, J5.1
/A0: J6.7, RN3.14 (R3.2), U2.12 (A0), U3.12 (A0), U4.12 (A0), U5.12 (A0), U11.2 (A0), U11.14 (A0)
/A0E: J1.12, J2.12, RN3.3 (R3.1)
/A1: J6.9, RN3.15 (R2.2), U2.11 (A1), U3.11 (A1), U4.11 (A1), U5.11 (A1), U7.12 (A0), U8.12 (A0), U9.12 (A0), U10.12 (A0)
/A1E: J1.11, J2.11, RN3.2 (R2.1)
/A2: J6.11, RN3.16 (R1.2), U2.10 (A2), U3.10 (A2), U4.10 (A2), U5.10 (A2), U7.11 (A1), U8.11 (A1), U9.11 (A1), U10.11 (A1)
/A2E: J1.10, J2.10, RN3.1 (R1.1)
/A3: J6.13, RN1.9 (R8.2), U2.9 (A3), U3.9 (A3), U4.9 (A3), U5.9 (A3), U7.10 (A2), U8.10 (A2), U9.10 (A2), U10.10 (A2)
/A3E: J1.9, J2.9, RN1.8 (R8.1)
/A4: J6.5, RN1.10 (R7.2), U2.8 (A4), U3.8 (A4), U4.8 (A4), U5.8 (A4), U7.9 (A3), U8.9 (A3), U9.9 (A3), U10.9 (A3)
/A4E: J1.8, J2.8, RN1.7 (R7.1)
/A5: J6.14, RN1.11 (R6.2), U2.7 (A5), U3.7 (A5), U4.7 (A5), U5.7 (A5), U7.8 (A4), U8.8 (A4), U9.8 (A4), U10.8 (A4)
/A5E: J1.7, J2.7, RN1.6 (R6.1)
/A6: RN1.12 (R5.2), U2.6 (A6), U3.6 (A6), U4.6 (A6), U5.6 (A6), U7.7 (A5), U8.7 (A5), U9.7 (A5), U10.7 (A5)
/A6E: J1.6, J2.6, RN1.5 (R5.1)
/A7: RN1.13 (R4.2), U2.5 (A7), U3.5 (A7), U4.5 (A7), U5.5 (A7), U7.6 (A6), U8.6 (A6), U9.6 (A6), U10.6 (A6)
/A7E: J1.5, J2.5, RN1.4 (R4.1)
/A8: RN2.12 (R5.2), U2.27 (A8), U3.27 (A8), U4.27 (A8), U5.27 (A8), U7.5 (A7), U8.5 (A7), U9.5 (A7), U10.5 (A7)
/A8E: J1.27, J2.27, RN2.5 (R5.1)
/A9: RN2.11 (R6.2), U2.26 (A9), U3.26 (A9), U4.26 (A9), U5.26 (A9), U7.27 (A8), U8.27 (A8), U9.27 (A8), U10.27 (A8)
/A9E: J1.26, J2.26, RN2.6 (R6.1)
/A10: RN2.9 (R8.2), U2.23 (A10), U3.23 (A10), U4.23 (A10), U5.23 (A10), U7.26 (A9), U8.26 (A9), U9.26 (A9), U10.26 (A9)
/A10E: J1.23, J2.23, RN2.8 (R8.1)
/A11: RN2.10 (R7.2), U2.25 (A11), U3.25 (A11), U4.25 (A11), U5.25 (A11), U7.23 (A10), U8.23 (A10), U9.23 (A10), U10.23 (A10)
/A11E: J1.25, J2.25, RN2.7 (R7.1)
/A12: RN1.14 (R3.2), U2.4 (A12), U3.4 (A12), U4.4 (A12), U5.4 (A12), U7.25 (A11), U8.25 (A11), U9.25 (A11), U10.25 (A11)
/A12E: J1.4, J2.4, RN1.3 (R3.1)
/A13: RN2.13 (R4.2), U2.28 (A13), U3.28 (A13), U4.28 (A13), U5.28 (A13), U7.4 (A12), U8.4 (A12), U9.4 (A12), U10.4 (A12)
/A13E: J1.28, J2.28, RN2.4 (R4.1)
/A14: RN2.14 (R3.2), U2.29 (A14), U3.29 (A14), U4.29 (A14), U5.29 (A14), U7.28 (A13), U8.28 (A13), U9.28 (A13), U10.28 (A13)
/A14E: J1.29, J2.29, RN2.3 (R3.1)
/A15: RN1.15 (R2.2), U2.3 (A15), U3.3 (A15), U4.3 (A15), U5.3 (A15), U7.3 (A14), U8.3 (A14), U9.3 (A14), U10.3 (A14)
/A15E: J1.3, J2.3, RN1.2 (R2.1)
/A16: RN1.16 (R1.2), U2.2 (A16), U3.2 (A16), U4.2 (A16), U5.2 (A16), U7.31 (A15), U8.31 (A15), U9.31 (A15), U10.31 (A15)
/A16E: J1.2, J2.2, RN1.1 (R1.1)
/A17: RN2.15 (R2.2), U2.30 (A17), U3.30 (A17), U4.30 (A17), U5.30 (A17), U7.2 (A16), U8.2 (A16), U9.2 (A16), U10.2 (A16)
/A17E: J1.30, J2.30, RN2.2 (R2.1)
/A18: RN2.16 (R1.2), U2.31 (A18), U3.31 (A18), U4.31 (A18), U5.31 (A18), U7.30 (A17), U8.30 (A17), U9.30 (A17), U10.30 (A17)
/A18E: J1.31, J2.31, RN2.1 (R1.1)
/A19: RN5.6 (R6.1), U1.4, U6.2, U7.1 (A18), U8.1 (A18), U9.1 (A18), U10.1 (A18)
/A19E: J3.6, RN5.11 (R6.2)
/A20: RN5.5 (R5.1), U1.1, U6.1
/A20E: J3.5, RN5.12 (R5.2)
/D0: J6.17, RN3.13 (R4.2), U4.13 (D0), U5.13 (D0), U8.13 (D0), U10.13 (D0)
/D0E: J1.13, RN3.4 (R4.1)
/D1: J6.18, RN3.12 (R5.2), U4.14 (D1), U5.14 (D1), U8.14 (D1), U10.14 (D1)
/D1E: J1.14, RN3.5 (R5.1)
/D2: J6.19, RN3.11 (R6.2), U4.15 (D2), U5.15 (D2), U8.15 (D2), U10.15 (D2)
/D2E: J1.15, RN3.6 (R6.1)
/D3: J6.20, RN3.10 (R7.2), U4.17 (D3), U5.17 (D3), U8.17 (D3), U10.17 (D3)
/D3E: J1.17, RN3.7 (R7.1)
/D4: J6.21, RN3.9 (R8.2), U4.18 (D4), U5.18 (D4), U8.18 (D4), U10.18 (D4)
/D4E: J1.18, RN3.8 (R8.1)
/D5: J6.22, RN4.14 (R3.2), U4.19 (D5), U5.19 (D5), U8.19 (D5), U10.19 (D5)
/D5E: J1.19, RN4.3 (R3.1)
/D6: J6.23, RN4.15 (R2.2), U4.20 (D6), U5.20 (D6), U8.20 (D6), U10.20 (D6)
/D6E: J1.20, RN4.2 (R2.1)
/D7: J6.24, RN4.16 (R1.2), U4.21 (D7), U5.21 (D7), U8.21 (D7), U10.21 (D7)
/D7E: J1.21, RN4.1 (R1.1)
/D8: J6.25, RN5.1 (R1.1), U2.13 (D0), U3.13 (D0), U7.13 (D0), U9.13 (D0)
/D8E: J2.13, RN5.16 (R1.2)
/D9: J6.26, RN5.2 (R2.1), U2.14 (D1), U3.14 (D1), U7.14 (D1), U9.14 (D1)
/D9E: J2.14, RN5.15 (R2.2)
/D10: J6.27, RN5.3 (R3.1), U2.15 (D2), U3.15 (D2), U7.15 (D2), U9.15 (D2)
/D10E: J2.15, RN5.14 (R3.2)
/D11: J6.28, RN4.9 (R8.2), U2.17 (D3), U3.17 (D3), U7.17 (D3), U9.17 (D3)
/D11E: J2.17, RN4.8 (R8.1)
/D12: J6.29, RN4.10 (R7.2), U2.18 (D4), U3.18 (D4), U7.18 (D4), U9.18 (D4)
/D12E: J2.18, RN4.7 (R7.1)
/D13: J6.30, RN4.11 (R6.2), U2.19 (D5), U3.19 (D5), U7.19 (D5), U9.19 (D5)
/D13E: J2.19, RN4.6 (R6.1)
/D14: J6.31, RN4.12 (R5.2), U2.20 (D6), U3.20 (D6), U7.20 (D6), U9.20 (D6)
/D14E: J2.20, RN4.5 (R5.1)
/D15: J6.32, RN4.13 (R4.2), U2.21 (D7), U3.21 (D7), U7.21 (D7), U9.21 (D7)
/D15E: J2.21, RN4.4 (R4.1)
/INV_IN: JP5.2 (C), U1.12, U1.13
/INV_OUT: JP4.3 (B), U1.11
/NON_INV: JP4.1 (A), JP5.1 (A), JP6.2 (C)
/RWOE: J4.2, RN6.5 (R4.2)
/R~W: J6.2, RN5.4 (R4.1), U6.10, U11.3 (A1), U11.13 (A1)
/R~WE: J3.3, RN5.13 (R4.2)
//DTACK: J3.2
//IRQ6: J3.8
/~CLDSE: J1.24, R1.1
/~CLDS: R1.2, U6.12, U11.1 (E)
/~CS0: JP6.1 (A), RN5.7 (R7.1), U6.4
/~CS0E: J3.9, RN5.10 (R7.2)
/~CS3: J3.7, JP6.3 (B)
/~CS: J6.3, U6.11
/~CS1E: J4.1, R6.2, U6.9
/~CUDSE: J2.24, R2.1
/~CUDS: R2.2, U11.15 (E)
/~OE1: U10.24 (/OE), U11.6 (O2)
/~OE2: U8.24 (/OE), U11.7 (O3)
/~OE3: U9.24 (/OE), U11.10 (O2)
/~OE4: U7.24 (/OE), U11.9 (O3)
/~RESET: J3.1, J6.12, R3.1, U1.2
/~SCS: RN5.9 (R8.2), U7.22 (/CE), U8.22 (/CE), U9.22 (/CE), U10.22 (/CE)
/~SSCS: Q1.3 (C), R4.2, RN5.8 (R8.1)
/~WE1: U10.29 (/WE), U11.4 (O0)
/~WE2: U8.29 (/WE), U11.5 (O1)
/~WE3: U9.29 (/WE), U11.12 (O0)
/~WE4: U7.29 (/WE), U11.11 (O1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.1, C13.1, C14.1, C15.1, C16.2, C17.2, C18.2, C19.2, H1.1, H2.1, H3.1, H4.1, H5.1, J1.16, J1.22, J2.16, J2.22, J4.5, J5.2, J6.1, J6.15, J6.16, J6.33, J6.34, JP5.3 (B), U1.7 (GND), U2.16 (GND), U3.16 (GND), U4.16 (GND), U5.16 (GND), U6.7 (GND), U7.16 (GND), U8.16 (GND), U9.16 (GND), U10.16 (GND), U11.8 (GND)
unnamed: J6.10, JP4.2 (C)
unnamed: C8.1, Q1.1 (B), R3.2
unnamed: Q1.2 (E), U1.3, U1.5
unnamed: R5.2, U1.9, U1.10, U6.13
unnamed: RN6.1 (R1.1), U6.6
unnamed: RN6.8 (R1.2), U2.24 (/OE), U3.24 (/OE), U4.24 (/OE), U5.24 (/OE)
unnamed: RN6.2 (R2.1), U6.3
unnamed: RN6.7 (R2.2), U2.22 (/CE), U4.22 (/CE)
unnamed: RN6.3 (R3.1), U1.6
unnamed: RN6.6 (R3.2), U3.22 (/CE), U5.22 (/CE)
unnamed: RN6.4 (R4.1), U6.8
unnamed: U1.8, U6.5

Notes on the sheet:
27C4001 EPROMs
TK1 550317
Headers to be connected to the two 274001 (512k x 16 bits EPROMs)
TK3 550319
TK2 550318
TK4 550320

Board: 4 copper layers, 132.7 x 109.6 mm, 60 parts (0 on the bottom side), 117 nets.

## Commit log

2026-02-10 Initial import
2026-02-10 Add the schematics in pdf format.
2026-02-10 Add the Turbokit logo on silkscreen.
2026-02-11 Tweak the routing a little.
2026-02-11 Update routing, again.
2026-02-12 Pour copper in internal layers and connect it to +5V and GND.
2026-02-12 Spot a nasty error in the schematic. Correct the routing.
2026-02-14 Corrected a few errors in the schematic.
2026-02-14 Tweak position of connectors.
2026-02-14 Small tweaks.
2026-02-14 Generate Gerber and drill files.
2026-02-15 Add LICENSE.txt, update README.md, add screenshots and pdf export of the version 1.0 of the board as sent to fabrication.
2026-02-15 Add files of the original Turbokit.
2026-05-10 Update README.md adding a link to the GEM S2 article in my webpage.
2026-05-17 Correct an error affecting the Ramdisk.
